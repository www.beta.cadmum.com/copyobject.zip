# Autodesk Inventor part: Structure_Piece_10d
## iProperties
Created: 2007-01
Part Number: Structure_Piece_10d
Document SubType Name: Modeling
Density: 1 g/cm^3
