# Autodesk Inventor assembly: Assembly Support System
## iProperties
Created: 2006-12
Part Number: Assembly Support System
Document SubType Name: Assembly
Designer: RDGodetteII
Author: RDGodetteII
